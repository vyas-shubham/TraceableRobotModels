Commit message: SRMS_Canadarm: Removed base inertia as it is not necessary for robot arm representation.

File: SRMS_Canadarm/SRMS_Canadarm.urdf (robot description, URDF)
Before this commit: robot SRMS_Canadarm, 9 links, 8 joints
Links:
- link Base_SRMS: mass 1 -> None
